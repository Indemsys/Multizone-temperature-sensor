# IAR project MZTS.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 Freescale MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK66FN2M0VLQ18; CPU_MK66F18; USB_2VCOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  ICCARM.CCIncludePath2: $PROJ_DIR$; App; App\CAN; App\FreeMaster; App\MFS; App\MODBUS; App\Peripherial; App\MZTS_APP; App\Sound_player; App\USB_2VCOM; App\USB_commn; App\VT100; MKW40; config; config\common; GUI; GUI\Config; GUI\Core; GUI\Font; GUI\JPEG; GUI\JPEG\Doc; GUI\JPEG\Image; GUI\LCDDriver; GUI\MemDev; GUI\Widget; GUI\WM; mfs; mfs\source; mfs\source\generic; mfs\source\include; mqx; mqx\source; mqx\source\bsp; mqx\source\bsp\K66BLEZ1; mqx\source\fio; mqx\source\include; mqx\source\io; mqx\source\io\cm; mqx\source\io\debug; mqx\source\io\enet; mqx\source\io\enet\macnet; mqx\source\io\enet\phy; mqx\source\io\esdhc; mqx\source\io\gpio; mqx\source\io\gpio\kgpio; mqx\source\io\hwtimer; mqx\source\io\io_mem; mqx\source\io\io_null; mqx\source\io\lwgpio; mqx\source\io\pcb; mqx\source\io\pcb\mqxa; mqx\source\io\pipe; mqx\source\io\rtc; mqx\source\io\sdcard; mqx\source\io\sdcard\sdcard_esdhc; mqx\source\io\serial; mqx\source\io\serial\int; mqx\source\io\serial\polled; mqx\source\io\tfs; mqx\source\io\timer; mqx\source\io\usb; mqx\source\io\usb_dcd; mqx\source\io\usb_dcd\int; mqx\source\io\usb_dcd\polled; mqx\source\kernel; mqx\source\psp; mqx\source\psp\cortex_m; mqx\source\psp\cortex_m\compiler; mqx\source\psp\cortex_m\compiler\iar; mqx\source\psp\cortex_m\core; mqx\source\psp\cortex_m\core\M4; mqx\source\psp\cortex_m\cpu; mqx\source\string; mqx\source\tad; RTT; usb; usb\adapter; usb\device; usb\device\classes; usb\device\classes\audio; usb\device\classes\cdc; usb\device\classes\common; usb\device\classes\composite; usb\device\classes\hid; usb\device\classes\msd; usb\device\classes\phdc; usb\device\controller; usb\device\controller\ehci; usb\device\controller\khci; usb\hal; usb\include
  AARM.AUserIncludes: ..\config\common; ..\mfs\source\include; ..\mqx\source\bsp\K66BLEZ1; ..\mqx\source\include; ..\mqx\source\io\adc\kadc; ..\mqx\source\io\adc; ..\mqx\source\io\can\flexcan; ..\mqx\source\io\cm; ..\mqx\source\io\debug; ..\mqx\source\io\dma; ..\mqx\source\io\enet\macnet; ..\mqx\source\io\enet\phy; ..\mqx\source\io\enet; ..\mqx\source\io\esdhc; ..\mqx\source\io\flashx\freescale; ..\mqx\source\io\flashx; ..\mqx\source\io\gpio\kgpio; ..\mqx\source\io\gpio; ..\mqx\source\io\hwtimer; ..\mqx\source\io\i2c\int; ..\mqx\source\io\i2c\polled; ..\mqx\source\io\i2c; ..\mqx\source\io\io_mem; ..\mqx\source\io\io_null; ..\mqx\source\io\lpm; ..\mqx\source\io\lwadc; ..\mqx\source\io\lwgpio; ..\mqx\source\io\pcb\mqxa; ..\mqx\source\io\pcb; ..\mqx\source\io\pccard; ..\mqx\source\io\pcflash; ..\mqx\source\io\pipe; ..\mqx\source\io\rtc; ..\mqx\source\io\sai\dma; ..\mqx\source\io\sai; ..\mqx\source\io\sdcard\sdcard_esdhc; ..\mqx\source\io\sdcard\sdcard_spi; ..\mqx\source\io\sdcard; ..\mqx\source\io\serial; ..\mqx\source\io\spi; ..\mqx\source\io\tchres; ..\mqx\source\io\tfs; ..\mqx\source\io\timer; ..\mqx\source\io\usb; ..\mqx\source\io\usb_dcd\int; ..\mqx\source\io\usb_dcd\polled; ..\mqx\source\io\usb_dcd; ..\mqx\source\psp\cortex_m\compiler\iar; ..\mqx\source\psp\cortex_m\core\M4; ..\mqx\source\psp\cortex_m\cpu; ..\mqx\source\psp\cortex_m; ..\mqx\source\tad; ..\rtcs\source\include; ..\RTT; ..\shell\source\include; ..\usb\adapter; ..\usb\device\classes\audio; ..\usb\device\classes\cdc; ..\usb\device\classes\common; ..\usb\device\classes\composite; ..\usb\device\classes\hid; ..\usb\device\classes\msd; ..\usb\device\classes\phdc; ..\usb\device\controller\ehci; ..\usb\device\controller\khci; ..\usb\device\controller; ..\usb\device; ..\usb\hal; ..\usb\include; Application\FreeMaster; Application\MFS; Application\Peripherial; Application\USB; Application\VT100; Application; mqx\source\psp\cortex_m\compiler\iar; mqx\source\include; App; config\common; mqx\source\psp\cortex_m; mqx\source\psp\cortex_m\core\M4
  OBJCOPY.OOCOutputFile: MZTS.hex
  ILINK.IlinkOutputFile: MZTS.out
  ILINK.IlinkIcfFile: intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group MZTS/App
    App/: App.h App_logger.c App_logger.h CAN_communication.c CAN_communication.h CRC_utils.c CRC_utils.h Debug_io.c Debug_io.h Inputs_controller.c Inputs_controller.h LED_control.c LED_control.h Main.c Parameters.c Parameters.h RTOS_utils.c RTOS_utils.h Supervisor_task.c Supervisor_task.h TimeMan.c user_config.h WatchDogCtrl.c WatchDogCtrl.h
  group MZTS/App/FreeMaster
    App/FreeMaster/: freemaster_appcmd.c freemaster_os.c freemaster_pipes.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c Task_FreeMaster.c
  group MZTS/App/MFS
    App/MFS/: MFS_man.c
  group MZTS/App/MODBUS
    App/MODBUS/: Modbus.c Modbus_bsp.c Modbus_data.c Modbus_master_core.c Modbus_os.c Modbus_util.c
  group MZTS/App/MZTS_APP
    App/MZTS_APP/: MZTS_Analog_INs.c MZTS_Analog_INs.h MZTS_app.h MZTS_CAN.c MZTS_CAN.h MZTS_DS1Wire.c MZTS_DS1Wire.h MZTS_DS1Wire_Intf.c MZTS_DS1Wire_Intf.h MZTS_Filters.c MZTS_filters.h MZTS_FreeMaster_vars.c MZTS_FreeMaster_vars_map.c MZTS_FreeMaster_vars_map.h MZTS_FreemasterCmdMan.c MZTS_FreemasterCmdMan.h MZTS_LSM6DSO32.c MZTS_LSM6DSO32.h MZTS_outputs.c MZTS_outputs.h MZTS_Params.c MZTS_Params.h MZTS_pins_config.c MZTS_Sound.c MZTS_Sound.h MZTS_SPI_bus.c MZTS_SPI_bus.h MZTS_task.c MZTS_task.h MZTS_TFT_display_control.c MZTS_TFT_display_control.h
  group MZTS/App/Peripherial
    App/Peripherial/: K66BLEZ1_ADC.c K66BLEZ1_CAN.c K66BLEZ1_DAC.c K66BLEZ1_DMA.c K66BLEZ1_FTM.c K66BLEZ1_I2C.c K66BLEZ1_INIT_SYS.c K66BLEZ1_MKW40_Channel.c K66BLEZ1_MKW40_Channel.h K66BLEZ1_PINS.c K66BLEZ1_PIT.c K66BLEZ1_SPI.c K66BLEZ1_TPM.c K66BLEZ1_UART.c K66BLEZ1_VBAT_RAM.c
  group MZTS/App/Sound_player
    App/Sound_player/: Sound_gen.c Sound_list.c Sound_player.c Voice_announcer.c WAV_reader.c
  group MZTS/App/USB_2VCOM
    App/USB_2VCOM/: USB_composite_dev.c usb_device_descriptor.c USB_virtual_com1.c USB_virtual_com2.c
  group MZTS/App/USB_commn
    App/USB_commn/: USB_debug.c
  group MZTS/App/VT100
    App/VT100/: Monitor_serial_drv.c Monitor_usb_drv.c MonitorVT100.c
  group MZTS/GUI/Config
    GUI/Config/: GUI_X.c
  group MZTS/GUI/Core
    GUI/Core/: GUI2DLib.c GUI__AddSpaceHex.c GUI__CalcTextRect.c GUI__DivideRound.c GUI__DivideRound32.c GUI__GetCursorPos.c GUI__GetFontSizeY.c GUI__GetNumChars.c GUI__HandleEOLine.c GUI__IntersectRect.c GUI__IntersectRects.c GUI__memset.c GUI__memset16.c GUI__Read.c GUI__ReduceRect.c GUI__SetText.c GUI__strcmp.c GUI__strlen.c GUI__Wrap.c GUI_AddBin.c GUI_AddDec.c GUI_AddDecMin.c GUI_AddDecShift.c GUI_AddHex.c GUI_AddKeyMsgHook.c GUI_ALLOC_AllocInit.c GUI_ALLOC_AllocZero.c GUI_BMP.c GUI_BMP_Serialize.c GUI_CalcColorDist.c GUI_ClearRectEx.c GUI_Color2VisColor.c GUI_CursorArrowL.c GUI_CursorArrowLI.c GUI_CursorArrowLPx.c GUI_CursorArrowM.c GUI_CursorArrowMI.c GUI_CursorArrowMPx.c GUI_CursorArrowS.c GUI_CursorArrowSI.c GUI_CursorArrowSPx.c GUI_CursorCrossL.c GUI_CursorCrossLI.c GUI_CursorCrossLPx.c GUI_CursorCrossM.c GUI_CursorCrossMI.c GUI_CursorCrossMPx.c GUI_CursorCrossS.c GUI_CursorCrossSI.c GUI_CursorCrossSPx.c GUI_CursorHeaderM.c GUI_CursorHeaderMI.c GUI_CursorHeaderMPx.c GUI_CursorPal.c GUI_CursorPalI.c GUI_DispBin.c GUI_DispCEOL.c GUI_DispChar.c GUI_DispChars.c GUI_DispHex.c GUI_DispString.c GUI_DispStringAt.c GUI_DispStringAtCEOL.c GUI_DispStringHCenter.c GUI_DispStringInRect.c GUI_DispStringInRectEx.c GUI_DispStringInRectMax.c GUI_DispStringInRectWrap.c GUI_DispStringLen.c GUI_DrawBitmap.c GUI_DrawBitmapEx.c GUI_DrawBitmapExp.c GUI_DrawBitmapMag.c GUI_DrawFocusRect.c GUI_DrawGraph.c GUI_DrawHLine.c GUI_DrawPie.c GUI_DrawPixel.c GUI_DrawPolyline.c GUI_DrawRectEx.c GUI_DrawVLine.c GUI_ErrorOut.c GUI_Exec.c GUI_FillPolygon.c GUI_FillRect.c GUI_FillRectEx.c GUI_GetBitmapPixelColor.c GUI_GetBitmapPixelIndex.c GUI_GetClientRect.c GUI_GetColor.c GUI_GetDispPos.c GUI_GetFont.c GUI_GetFontInfo.c GUI_GetFontSizeY.c GUI_GetLineStyle.c GUI_GetStringDistX.c GUI_GetTextAlign.c GUI_GetTextExtend.c GUI_GetTextMode.c GUI_GetVersionString.c GUI_GetYSizeOfFont.c GUI_GIF.c GUI_Goto.c GUI_InitLUT.c GUI_InvertRect.c GUI_IsInFont.c GUI_Log.c GUI_MergeRect.c GUI_MOUSE.c GUI_MOUSE_DriverPS2.c GUI_MoveRect.c GUI_OnKey.c GUI_Pen.c GUI_PID.c GUI_RectsIntersect.c GUI_SaveContext.c GUI_ScreenSize.c GUI_SelectLayer.c GUI_SelectLCD.c GUI_SetClipRect.c GUI_SetColor.c GUI_SetColorIndex.c GUI_SetDecChar.c GUI_SetDefault.c GUI_SetDrawMode.c GUI_SetFont.c GUI_SetLBorder.c GUI_SetLineStyle.c GUI_SetLUTColor.c GUI_SetLUTColorEx.c GUI_SetLUTEntry.c GUI_SetOrg.c GUI_SetPixelIndex.c GUI_SetTextAlign.c GUI_SetTextMode.c GUI_SetTextStyle.c GUI_SIF.c GUI_SIF_Prop.c GUI_TOUCH.c GUI_TOUCH_DriverAnalog.c GUI_TOUCH_StoreState.c GUI_TOUCH_StoreUnstable.c GUI_UC.c GUI_UC_DispString.c GUI_UC_EncodeNone.c GUI_UC_EncodeUTF8.c GUI_WaitEvent.c GUI_WaitKey.c GUI_Warn.c GUIAlloc.c GUIArc.c GUIChar.c GUICharLine.c GUICharM.c GUICharP.c GUICirc.c GUIColor2Index.c GUICore.c GUICurs.c GUIEncJS.c GUIIndex2Color.c GUIPolyE.c GUIPolyM.c GUIPolyR.c GUIRealloc.c GUIStream.c GUITask.c GUITime.c GUITimer.c GUIUC0.c GUIVal.c GUIValf.c LCD.c LCD_API.c LCD_DrawBitmap_565.c LCD_DrawBitmap_M565.c LCD_DrawVLine.c LCD_GetColorIndex.c LCD_GetEx.c LCD_GetNumDisplays.c LCD_GetPixelColor.c LCD_Index2ColorEx.c LCD_L0_Generic.c LCD_Mirror.c LCD_MixColors256.c LCD_Rotate180.c LCD_RotateCCW.c LCD_RotateCW.c LCD_SelectLCD.c LCD_SetAPI.c LCD_SetClipRectEx.c LCD_UpdateColorIndices.c LCDAA.c LCDColor.c LCDGetP.c LCDInfo.c LCDInfo0.c LCDInfo1.c LCDL0Delta.c LCDL0Mag.c LCDP1.c LCDP565_Index2Color.c LCDPM565_Index2Color.c LCDRLE4.c LCDRLE8.c
  group MZTS/GUI/Font
    GUI/Font/: F08_1.c F08_ASCII.c F10_1.c F10_ASCII.c F10S_1.c F10S_ASCII.c F13_1.c F13_ASCII.c F13B_1.c F13B_ASCII.c F13H_1.c F13H_ASCII.c F13HB_1.c F13HB_ASCII.c F16_1.c F16_1HK.c F16_ASCII.c F16_HK.c F16B_1.c F16B_ASCII.c F24_1.c F24_ASCII.c F24B_1.c F24B_ASCII.c F32_1.c F32_ASCII.c F32B_1.c F32B_ASCII.c F4x6.c F6x8.c F8x10_ASCII.c F8x12_ASCII.c F8x13_1.c F8x13_ASCII.c F8x15B_1.c F8x15B_ASCII.c F8x16.c F8x8.c FComic18B_1.c FComic18B_ASCII.c FComic24B_1.c FComic24B_ASCII.c FD24x32.c FD32.c FD36x48.c FD48.c FD48x64.c FD60x80.c FD64.c FD80.c
  group MZTS/GUI/JPEG
    GUI/JPEG/: GUI_JPEG.c jcomapi.c jdapimin.c jdapistd.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdphuff.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jidctred.c jmemmgr.c jquant1.c jquant2.c jutils.c
  group MZTS/GUI/LCDDriver
    GUI/LCDDriver/: ST7789VW_gui_driver.c
  group MZTS/GUI/MemDev
    GUI/MemDev/: GUIDEV.c GUIDEV_1.c GUIDEV_16.c GUIDEV_8.c GUIDEV_AA.c GUIDEV_Auto.c GUIDEV_Banding.c GUIDEV_Clear.c GUIDEV_CmpWithLCD.c GUIDEV_CopyFromLCD.c GUIDEV_CreateFixed.c GUIDEV_GetDataPtr.c GUIDEV_GetXSize.c GUIDEV_GetYSize.c GUIDEV_Measure.c GUIDEV_ReduceYSize.c GUIDEV_SetOrg.c GUIDEV_Usage.c GUIDEV_UsageBM.c GUIDEV_Write.c GUIDEV_WriteAlpha.c GUIDEV_WriteEx.c GUIDEV_XY2PTR.c
  group MZTS/GUI/Widget
    GUI/Widget/: BUTTON.c BUTTON__SetBitmapObj.c BUTTON_Bitmap.c BUTTON_BMP.c BUTTON_Create.c BUTTON_CreateIndirect.c BUTTON_Default.c BUTTON_Get.c BUTTON_IsPressed.c BUTTON_SelfDraw.c BUTTON_SetTextAlign.c BUTTON_StreamedBitmap.c CHECKBOX.c CHECKBOX_Create.c CHECKBOX_CreateIndirect.c CHECKBOX_Default.c CHECKBOX_GetState.c CHECKBOX_Image.c CHECKBOX_IsChecked.c CHECKBOX_SetBkColor.c CHECKBOX_SetDefaultImage.c CHECKBOX_SetFont.c CHECKBOX_SetImage.c CHECKBOX_SetNumStates.c CHECKBOX_SetSpacing.c CHECKBOX_SetState.c CHECKBOX_SetText.c CHECKBOX_SetTextAlign.c CHECKBOX_SetTextColor.c DIALOG.c DROPDOWN.c DROPDOWN_Create.c DROPDOWN_CreateIndirect.c DROPDOWN_DeleteItem.c DROPDOWN_InsertString.c DROPDOWN_ItemSpacing.c DROPDOWN_SetAutoScroll.c DROPDOWN_SetTextAlign.c DROPDOWN_SetTextHeight.c EDIT.c EDIT_Create.c EDIT_CreateIndirect.c EDIT_Default.c EDIT_GetCursorPixelPos.c EDIT_GetCursorPos.c EDIT_GetNumChars.c EDIT_SetCursorAtChar.c EDIT_SetFocussable.c EDIT_SetInsertMode.c EDIT_SetpfAddKeyEx.c EDIT_SetpfUpdateBuffer.c EDIT_SetSel.c EDIT_SetTextMode.c EDITBin.c EDITDec.c EDITFloat.c EDITHex.c EDITUlong.c FRAMEWIN.c FRAMEWIN__UpdateButtons.c FRAMEWIN_AddMenu.c FRAMEWIN_Button.c FRAMEWIN_ButtonClose.c FRAMEWIN_ButtonMax.c FRAMEWIN_ButtonMin.c FRAMEWIN_Create.c FRAMEWIN_CreateIndirect.c FRAMEWIN_Default.c FRAMEWIN_Get.c FRAMEWIN_IsMinMax.c FRAMEWIN_MinMaxRest.c FRAMEWIN_SetBorderSize.c FRAMEWIN_SetColors.c FRAMEWIN_SetFont.c FRAMEWIN_SetResizeable.c FRAMEWIN_SetTitleHeight.c FRAMEWIN_SetTitleVis.c GUI_ARRAY.c GUI_ARRAY_DeleteItem.c GUI_ARRAY_InsertItem.c GUI_ARRAY_ResizeItem.c GUI_DRAW.c GUI_DRAW_BITMAP.c GUI_DRAW_BMP.c GUI_DRAW_Self.c GUI_DRAW_STREAMED.c GUI_EditBin.c GUI_EditDec.c GUI_EditFloat.c GUI_EditHex.c GUI_EditString.c GUI_HOOK.c HEADER.c HEADER__SetDrawObj.c HEADER_Bitmap.c HEADER_BMP.c HEADER_Create.c HEADER_CreateIndirect.c HEADER_StreamedBitmap.c LISTBOX.c LISTBOX_Create.c LISTBOX_CreateIndirect.c LISTBOX_Default.c LISTBOX_DeleteItem.c LISTBOX_Font.c LISTBOX_GetItemText.c LISTBOX_GetNumItems.c LISTBOX_InsertString.c LISTBOX_ItemDisabled.c LISTBOX_ItemSpacing.c LISTBOX_MultiSel.c LISTBOX_ScrollStep.c LISTBOX_SetAutoScroll.c LISTBOX_SetBkColor.c LISTBOX_SetOwner.c LISTBOX_SetOwnerDraw.c LISTBOX_SetScrollbarWidth.c LISTBOX_SetString.c LISTBOX_SetTextColor.c LISTVIEW.c LISTVIEW_Create.c LISTVIEW_CreateIndirect.c LISTVIEW_Default.c LISTVIEW_DeleteColumn.c LISTVIEW_DeleteRow.c LISTVIEW_GetBkColor.c LISTVIEW_GetFont.c LISTVIEW_GetHeader.c LISTVIEW_GetNumColumns.c LISTVIEW_GetNumRows.c LISTVIEW_GetSel.c LISTVIEW_GetTextColor.c LISTVIEW_SetBkColor.c LISTVIEW_SetColumnWidth.c LISTVIEW_SetFont.c LISTVIEW_SetGridVis.c LISTVIEW_SetItemColor.c LISTVIEW_SetItemText.c LISTVIEW_SetLBorder.c LISTVIEW_SetRBorder.c LISTVIEW_SetRowHeight.c LISTVIEW_SetSel.c LISTVIEW_SetTextAlign.c LISTVIEW_SetTextColor.c MENU.c MENU__FindItem.c MENU_Attach.c MENU_CreateIndirect.c MENU_Default.c MENU_DeleteItem.c MENU_DisableItem.c MENU_EnableItem.c MENU_GetItem.c MENU_GetItemText.c MENU_GetNumItems.c MENU_InsertItem.c MENU_Popup.c MENU_SetBkColor.c MENU_SetBorderSize.c MENU_SetFont.c MENU_SetItem.c MENU_SetTextColor.c MESSAGEBOX.c MULTIEDIT.c MULTIEDIT_Create.c MULTIEDIT_CreateIndirect.c MULTIPAGE.c MULTIPAGE_Create.c MULTIPAGE_CreateIndirect.c MULTIPAGE_Default.c PROGBAR.c PROGBAR_Create.c PROGBAR_CreateIndirect.c RADIO.c RADIO_Create.c RADIO_CreateIndirect.c RADIO_Default.c RADIO_Image.c RADIO_SetBkColor.c RADIO_SetDefaultImage.c RADIO_SetFont.c RADIO_SetGroupId.c RADIO_SetImage.c RADIO_SetText.c RADIO_SetTextColor.c SCROLLBAR.c SCROLLBAR_Create.c SCROLLBAR_CreateIndirect.c SCROLLBAR_Defaults.c SCROLLBAR_GetValue.c SCROLLBAR_SetWidth.c SLIDER.c SLIDER_Create.c SLIDER_CreateIndirect.c TEXT.c TEXT_Create.c TEXT_CreateIndirect.c TEXT_Default.c TEXT_SetBkColor.c TEXT_SetFont.c TEXT_SetText.c TEXT_SetTextAlign.c TEXT_SetTextColor.c TEXT_SetWrapMode.c WIDGET.c WIDGET_Effect_3D.c WIDGET_Effect_3D1L.c WIDGET_Effect_3D2L.c WIDGET_Effect_None.c WIDGET_Effect_Simple.c WIDGET_FillStringInRect.c WIDGET_SetEffect.c WIDGET_SetWidth.c WINDOW.c WINDOW_Default.c
  group MZTS/GUI/WM
    GUI/WM/: WM.c WM__ForEachDesc.c WM__GetFirstSibling.c WM__GetFocussedChild.c WM__GetLastSibling.c WM__GetOrg_AA.c WM__GetPrevSibling.c WM__IsAncestor.c WM__IsChild.c WM__IsEnabled.c WM__NotifyVisChanged.c WM__Screen2Client.c WM__SendMessage.c WM__SendMessageIfEnabled.c WM__SendMessageNoPara.c WM__UpdateChildPositions.c WM_AttachWindow.c WM_BringToBottom.c WM_BringToTop.c WM_Broadcast.c WM_CheckScrollPos.c WM_CriticalHandle.c WM_DIAG.c WM_EnableWindow.c WM_ForEachDesc.c WM_GetBkColor.c WM_GetClientRect.c WM_GetClientWindow.c WM_GetDesktopWindow.c WM_GetDesktopWindowEx.c WM_GetDiagInfo.c WM_GetDialogItem.c WM_GetFirstChild.c WM_GetFlags.c WM_GetFocussedWindow.c WM_GetId.c WM_GetInsideRect.c WM_GetInsideRectExScrollbar.c WM_GetInvalidRect.c WM_GetNextSibling.c WM_GetOrg.c WM_GetParent.c WM_GetPrevSibling.c WM_GetScrollbar.c WM_GetScrollPartner.c WM_GetScrollState.c WM_GetWindowRect.c WM_GetWindowSize.c WM_HasCaptured.c WM_HasFocus.c WM_Hide.c WM_IsCompletelyVisible.c WM_IsEnabled.c WM_IsFocussable.c WM_IsVisible.c WM_IsWindow.c WM_MakeModal.c WM_Move.c WM_MoveChildTo.c WM_NotifyParent.c WM_OnKey.c WM_Paint.c WM_PID__GetPrevState.c WM_ResizeWindow.c WM_Screen2Win.c WM_SendMessageNoPara.c WM_SendToParent.c WM_SetAnchor.c WM_SetCallback.c WM_SetCapture.c WM_SetCaptureMove.c WM_SetCreateFlags.c WM_SetDesktopColor.c WM_SetFocus.c WM_SetFocusOnNextChild.c WM_SetFocusOnPrevChild.c WM_SetId.c WM_SetpfPollPID.c WM_SetScrollbar.c WM_SetScrollState.c WM_SetSize.c WM_SetTrans.c WM_SetTransState.c WM_SetUserClipRect.c WM_SetXSize.c WM_SetYSize.c WM_Show.c WM_StayOnTop.c WM_Timer.c WM_TimerExternal.c WM_UserData.c WM_Validate.c WM_ValidateWindow.c WMMemDev.c WMTouch.c
  group MZTS/mfs/source/generic
    mfs/source/generic/: dir_read.c mfs_attribute.c mfs_cache.c mfs_chain.c mfs_cluster.c mfs_delete.c mfs_dir_chain.c mfs_dir_entry.c mfs_directory.c mfs_fat.c mfs_find.c mfs_fio.c mfs_flush.c mfs_format.c mfs_globals.c mfs_handle.c mfs_ioctl.c mfs_lfn.c mfs_misc.c mfs_mount.c mfs_open.c mfs_parse.c mfs_read.c mfs_rename.c mfs_rw.c mfs_search.c mfs_time.c mfs_unicode.c mfs_valdev.c mfs_write.c part_mgr.c
  group MZTS/MKW40
    MKW40/: MKW40_Channel.c MKW40_Channel.h MKW40_comm_channel_IDs.h
  group MZTS/mqx/source/bsp/K66BLEZ1
    mqx/source/bsp/K66BLEZ1/: bsp_cm.c init_bsp.c init_enet.c init_esdhc.c init_gpio.c init_hw.c init_iodebug.c init_sci.c init_sdcard.c init_usb.c init_usb_dcd.c mqx_init.c mqx_main.c Sdelay.S vectors.c
  group MZTS/mqx/source/fio
    mqx/source/fio/: io_clre.c io_dopr.c io_fclos.c io_feof.c io_ferr.c io_fflsh.c io_fgetc.c io_fgetl.c io_fgets.c io_fopen.c io_fp.c io_fprt.c io_fputc.c io_fputs.c io_fscan.c io_fseek.c io_fstat.c io_ftell.c io_fung.c io_ioctl.c io_misc.c io_pntf.c io_read.c io_scanf.c io_scanl.c io_spr.c io_sscan.c io_util.c io_vpr.c io_write.c
  group MZTS/mqx/source/io
    mqx/source/io/: io_ghand.c io_init.c io_inst.c io_instx.c io_shand.c io_uinst.c
  group MZTS/mqx/source/io/cm
    mqx/source/io/cm/: cm.c
  group MZTS/mqx/source/io/debug
    mqx/source/io/debug/: iodebug.c iodebug_asm.S
  group MZTS/mqx/source/io/enet
    mqx/source/io/enet/: enaddr.c enclose.c enerr.c eninit.c enjoin.c enleave.c enmediactl.c enopen.c enrecv.c ensend.c enstat.c enstop.c enutil.c
  group MZTS/mqx/source/io/enet/macnet
    mqx/source/io/enet/macnet/: macnet_1588.c macnet_init.c macnet_join.c macnet_mii.c macnet_mk65.c macnet_receive.c macnet_rejoin.c macnet_send.c macnet_stop.c macnet_util.c
  group MZTS/mqx/source/io/enet/phy
    mqx/source/io/enet/phy/: phy_ksz8041.c
  group MZTS/mqx/source/io/esdhc
    mqx/source/io/esdhc/: esdhc.c esdhc_mk65.c
  group MZTS/mqx/source/io/gpio
    mqx/source/io/gpio/: io_gpio.c
  group MZTS/mqx/source/io/gpio/kgpio
    mqx/source/io/gpio/kgpio/: io_gpio_kgpio.c
  group MZTS/mqx/source/io/hwtimer
    mqx/source/io/hwtimer/: hwtimer.c hwtimer_kinetis.c hwtimer_lpt.c hwtimer_pit.c hwtimer_systick.c
  group MZTS/mqx/source/io/io_mem
    mqx/source/io/io_mem/: io_mem.c
  group MZTS/mqx/source/io/io_null
    mqx/source/io/io_null/: io_null.c
  group MZTS/mqx/source/io/lwgpio
    mqx/source/io/lwgpio/: lwgpio.c lwgpio_kgpio.c
  group MZTS/mqx/source/io/pcb
    mqx/source/io/pcb/: io_pcb.c io_pcb2.c
  group MZTS/mqx/source/io/pcb/mqxa
    mqx/source/io/pcb/mqxa/: pcb_mqxa.c
  group MZTS/mqx/source/io/pipe
    mqx/source/io/pipe/: io_pipe.c
  group MZTS/mqx/source/io/rtc
    mqx/source/io/rtc/: krtc.c
  group MZTS/mqx/source/io/sdcard
    mqx/source/io/sdcard/: sdcard.c
  group MZTS/mqx/source/io/sdcard/sdcard_esdhc
    mqx/source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.c
  group MZTS/mqx/source/io/serial
    mqx/source/io/serial/: io_sinit.c serl_mk65.c
  group MZTS/mqx/source/io/serial/int
    mqx/source/io/serial/int/: serl_int.c serl_int_kuart.c
  group MZTS/mqx/source/io/serial/polled
    mqx/source/io/serial/polled/: serl_pol.c serl_pol_kuart.c
  group MZTS/mqx/source/io/tfs
    mqx/source/io/tfs/: tfs.c
  group MZTS/mqx/source/io/timer
    mqx/source/io/timer/: timer_kinetis.c timer_qpit.c
  group MZTS/mqx/source/io/usb
    mqx/source/io/usb/: usb_install.c usb_mk65f.c usb_mk65f_device.c
  group MZTS/mqx/source/io/usb_dcd
    mqx/source/io/usb_dcd/: usb_dcd_mk65.c
  group MZTS/mqx/source/io/usb_dcd/int
    mqx/source/io/usb_dcd/int/: usb_dcd_int.c usb_dcd_int_kn.c
  group MZTS/mqx/source/io/usb_dcd/polled
    mqx/source/io/usb_dcd/polled/: usb_dcd_pol.c usb_dcd_pol_kn.c
  group MZTS/mqx/source/kernel
    mqx/source/kernel/: event.c idletask.c inittask.c int.c ipc.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwsem.c lwtimer.c mem.c mqx.c msg.c msgpool.c msgq.c mutex.c name.c partition.c queue.c sched.c sem.c task.c taskq.c time.c timer.c tlsf.c tlsf_adaptation.c watchdog.c
  group MZTS/mqx/source/psp/cortex_m
    mqx/source/psp/cortex_m/: cortex.c int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c k_assert.c kinetis_mpu.c mem_copy.c mem_zero.c nvic.c psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_psti.c psp_seti.c psp_supp.c psp_tiad.c psp_tida.c psp_tihr.c psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c
  group MZTS/mqx/source/psp/cortex_m/compiler/iar
    mqx/source/psp/cortex_m/compiler/iar/: comp.c kernel_symbols.S
  group MZTS/mqx/source/psp/cortex_m/core/M4
    mqx/source/psp/cortex_m/core/M4/: boot.S dispatch.S support.S
  group MZTS/mqx/source/string
    mqx/source/string/: str_utos.c strnlen.c
  group MZTS/mqx/source/tad
    mqx/source/tad/: tad.c
  group MZTS/RTT
    RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group MZTS/usb/adapter
    usb/adapter/: adapter_mqx.c
  group MZTS/usb/device
    usb/device/: usb_dev_bsp.c
  group MZTS/usb/device/classes/audio
    usb/device/classes/audio/: usb_audio.c
  group MZTS/usb/device/classes/cdc
    usb/device/classes/cdc/: usb_cdc.c usb_cdc_pstn.c
  group MZTS/usb/device/classes/common
    usb/device/classes/common/: usb_class.c
  group MZTS/usb/device/classes/composite
    usb/device/classes/composite/: usb_composite.c
  group MZTS/usb/device/classes/hid
    usb/device/classes/hid/: usb_hid.c
  group MZTS/usb/device/classes/msd
    usb/device/classes/msd/: usb_msc.c usb_msc_scsi.c
  group MZTS/usb/device/classes/phdc
    usb/device/classes/phdc/: usb_phdc.c
  group MZTS/usb/device/controller
    usb/device/controller/: usb_dev.c usb_framework.c
  group MZTS/usb/device/controller/ehci
    usb/device/controller/ehci/: device_ehci_interface.c ehci_dev_main.c
  group MZTS/usb/device/controller/khci
    usb/device/controller/khci/: device_khci_interface.c khci_dev.c
