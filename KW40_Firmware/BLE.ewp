# IAR project BLE.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW40Z160xxx4 Freescale MKW40Z160xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; IAR; CPU_MKW40Z160VHT4; FSL_RTOS_FREE_RTOS; USB_KW40Z; DONGLE
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: App\App_config.h
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ICCARM.CCIncludePath2: App; App\RTT; BLE; BLE\BLE_Stack; BLE\GATT_DB; BLE\GATT_DB\macros; BLE\Services; BLE\Services\Battery_Service; BLE\Services\DeviceInfo_Service; BLE\Services\HeartRate_Service; BLE\Services\HID_Service; BLE\Services\ImmediateAlert_Service; BLE\Services\LinkLoss_Service; BLE\Services\TxPower_Service; OS; OS\FreeRTOS; OS\FreeRTOS\config; OS\FreeRTOS\include; OS\FreeRTOS\port; OS\FreeRTOS\src; OS\OSAbstractionLayer; Platform; Platform\CMSIS; Platform\Framework; Platform\Framework\Flash; Platform\FSL; Platform\HAL
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..\App\RTT; ..\App; ..\BLE\BLE_Stack; ..\BLE\GATT_DB\macros; ..\BLE\GATT_DB; ..\BLE\Services\Battery_Service; ..\BLE\Services\DeviceInfo_Service; ..\BLE\Services\HeartRate_Service; ..\BLE\Services\HID_Service; ..\BLE\Services\ImmediateAlert_Service; ..\BLE\Services\K66BLEZ_services; ..\BLE\Services\LinkLoss_Service; ..\BLE\Services\TxPower_Service; ..\BLE; ..\OS\FreeRTOS\config; ..\OS\FreeRTOS\include; ..\OS\FreeRTOS\port; ..\OS\OSAbstractionLayer; ..\Platform\CMSIS; ..\Platform\Framework\Flash; ..\Platform\Framework; ..\Platform\FSL; ..\Platform\HAL; ..\Platform; ..\OS\FreeRTOS\config
  OBJCOPY.OOCOutputFile: BLE.hex
  ILINK.IlinkOutputFile: BLE.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; __heap_size__=0; __stack_size__=384; __ram_vector_table__=1
  ILINK.IlinkIcfFile: MKW40Z160xxx4_BLE.icf
  ILINK.IlinkAdditionalLibs: BLE\BLE_Stack\ble_host_lib.a; BLE\BLE_Stack\ble_controller_lib.a; BLE\BLE_Stack\lib_crypto_IAR_M0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; CPU_MKW40Z160VHT4
  ICCARM.PreInclude: examples/bluetooth/hid_device/frdmkw40z/FreeRTOS/app_preinclude.h
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: ..\App\RTT; ..\App; ..\BLE\BLE_Stack; ..\BLE\GATT_DB\macros; ..\BLE\GATT_DB; ..\BLE\Services\Battery_Service; ..\BLE\Services\DeviceInfo_Service; ..\BLE\Services\HeartRate_Service; ..\BLE\Services\HID_Service; ..\BLE\Services\ImmediateAlert_Service; ..\BLE\Services\K66BLEZ_services; ..\BLE\Services\LinkLoss_Service; ..\BLE\Services\TxPower_Service; ..\BLE; ..\OS\FreeRTOS\config; ..\OS\FreeRTOS\include; ..\OS\FreeRTOS\port; ..\OS\OSAbstractionLayer; ..\Platform\CMSIS; ..\Platform\Framework\Flash; ..\Platform\Framework; ..\Platform\FSL; ..\Platform\HAL; ..\Platform
  OBJCOPY.OOCOutputFile: generic.bin
  ILINK.IlinkOutputFile: hid_device_FreeRTOS.out
  ILINK.IlinkIcfFile: platform/devices/MKW40Z4/linker/iar/MKW40Z160xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: bluetooth/host/lib/ble_host_peripheral_lib.a; $_KSDK_1_3_0_PATH_$\lib\ksdk_freertos_lib\iar\KW40Z4\release\libksdk_platform_freertos.a; framework/SecLib/lib_crypto_IAR_M0.a; bluetooth/controller/lib/ble_controller_lib.a
  group KW40_Firmware/App
    App/: App.h App_comm_channel.c App_comm_channel.h App_CommandService.c App_CommandService.h App_CommunicationService.c App_CommunicationService.h App_config.h App_Debug_print.h BLE_Perfomance_Test.c BLE_Perfomance_Test.h CRC_utils.c CRC_utils.h Main.c MKW40_comm_channel_IDs.h
  group KW40_Firmware/App/RTT
    App/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group KW40_Firmware/BLE
    BLE/: BLE_common_app.c BLE_common_app.h ble_controller_task.c ble_controller_task_config.h ble_host_tasks.c ble_host_tasks.h BLE_peripheral_app.c BLE_peripheral_app.h
  group KW40_Firmware/BLE/BLE_Stack
    BLE/BLE_Stack/: att_errors.h att_types.h ble_constants.h ble_general.h ble_globals.c ble_sig_defines.h ble_utils.h controller_interface.h fsl_debug_console.h gap_interface.h gap_types.h gatt_client_interface.h gatt_db_app_interface.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_transport.h hci_types.h hcit_serial_interface.c l2ca_cb_interface.h l2ca_interface.h l2ca_types.h Phy.h PhyInterface.h PhyMessages.h PhyTypes.h smp_packets.h smp_types.h vendor_debug_commands.h
  group KW40_Firmware/BLE/GATT_DB
    BLE/GATT_DB/: gatt_database.c gatt_database.h gatt_db.h gatt_db_handles.h gatt_uuid128.h
  group KW40_Firmware/BLE/GATT_DB/macros
    BLE/GATT_DB/macros/: gatt_db_macros.h
  group KW40_Firmware/BLE/Services/Battery_Service
    BLE/Services/Battery_Service/: battery_interface.h battery_service.c
  group KW40_Firmware/BLE/Services/DeviceInfo_Service
    BLE/Services/DeviceInfo_Service/: device_info_interface.h device_info_service.c
  group KW40_Firmware/BLE/Services/HeartRate_Service
    BLE/Services/HeartRate_Service/: heart_rate_client.c heart_rate_interface.h heart_rate_service.c
  group KW40_Firmware/BLE/Services/HID_Service
    BLE/Services/HID_Service/: hid_interface.h hid_service.c
  group KW40_Firmware/BLE/Services/ImmediateAlert_Service
    BLE/Services/ImmediateAlert_Service/: immediate_alert_interface.h immediate_alert_service.c
  group KW40_Firmware/BLE/Services/LinkLoss_Service
    BLE/Services/LinkLoss_Service/: link_loss_interface.h link_loss_service.c
  group KW40_Firmware/BLE/Services/TxPower_Service
    BLE/Services/TxPower_Service/: tx_power_interface.h tx_power_service.c
  group KW40_Firmware/OS/FreeRTOS/config
    OS/FreeRTOS/config/: FreeRTOSConfig.h
  group KW40_Firmware/OS/FreeRTOS/include
    OS/FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group KW40_Firmware/OS/FreeRTOS/port
    OS/FreeRTOS/port/: port.c portasm.s portmacro.h portTicks.h
  group KW40_Firmware/OS/FreeRTOS/src
    OS/FreeRTOS/src/: croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c list.c queue.c tasks.c timers.c
  group KW40_Firmware/OS/OSAbstractionLayer
    OS/OSAbstractionLayer/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group KW40_Firmware/Platform
    Platform/: BSP.c BSP.h BSP_clocks.c BSP_clocks.h BSP_DMA.c BSP_DMA.h BSP_pins.c BSP_pins.h BSP_PIT.c BSP_PIT.h BSP_SPI.c BSP_SPI.h startup_MKW40Z4.s
  group KW40_Firmware/Platform/CMSIS
    Platform/CMSIS/: core_cm0plus.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group KW40_Firmware/Platform/Framework
    Platform/Framework/: BLEDefaults.h DCDC.c DCDC.h EmbeddedTypes.h fsl_osa_ext.h FunctionLib.c FunctionLib.h FwkInit.c GenericList.c GenericList.h GPIO_IrqAdapter.c Gpio_IrqAdapter.h ifr_mkw40z4_radio.c ifr_mkw40z4_radio.h KW4xXcvrDrv.c KW4xXcvrDrv.h MemManager.c MemManager.h Messaging.c Messaging.h ModuleInfo.h overwrites.h Panic.c Panic.h PWR.c PWR_BLE.c PWR_BLE.h PWR_Configuration.h PWR_Interface.h PWR_Platform.c PWR_Platform.h PWRLib.c PWRLib.h Reset.c RNG.c RNG_Interface.h SecLib.c SecLib.h SerialManager.c SerialManager.h TimersManager.c TimersManager.h TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h tsm_ll_timing.c tsm_ll_timing.h tsm_timing_ble.h tsm_timing_zigbee.h ZigbeeDefaults.h
  group KW40_Firmware/Platform/Framework/Flash
    Platform/Framework/Flash/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c Flash_Adapter.c Flash_Adapter.h FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c FTFx_KX_flash_config.h PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group KW40_Firmware/Platform/FSL
    Platform/FSL/: fsl_adc16_common.c fsl_adc16_driver.c fsl_adc16_driver.h fsl_bitaccess.h fsl_clock_manager.c fsl_clock_manager.h fsl_clock_manager_common.c fsl_clock_MKW40Z4.c fsl_clock_MKW40Z4.h fsl_cmp_common.c fsl_cmp_driver.c fsl_cmp_driver.h fsl_cmt_common.c fsl_cmt_driver.c fsl_cmt_driver.h fsl_cop_common.c fsl_cop_driver.c fsl_cop_driver.h fsl_dac_common.c fsl_dac_driver.c fsl_dac_driver.h fsl_device_registers.h fsl_dma_common.c fsl_dma_driver.c fsl_dma_driver.h fsl_dma_request.h fsl_dspi_common.c fsl_dspi_dma_master_driver.c fsl_dspi_dma_master_driver.h fsl_dspi_dma_slave_driver.c fsl_dspi_dma_slave_driver.h fsl_dspi_master_driver.c fsl_dspi_master_driver.h fsl_dspi_shared_function.c fsl_dspi_shared_function.h fsl_dspi_slave_driver.c fsl_dspi_slave_driver.h fsl_gpio_common.c fsl_gpio_driver.c fsl_gpio_driver.h fsl_hwtimer.c fsl_hwtimer.h fsl_hwtimer_pit.c fsl_hwtimer_pit.h fsl_hwtimer_systick.c fsl_hwtimer_systick.h fsl_interrupt_manager.c fsl_interrupt_manager.h fsl_lptmr_common.c fsl_lptmr_driver.c fsl_lptmr_driver.h fsl_lpuart_common.c fsl_lpuart_dma_driver.c fsl_lpuart_dma_driver.h fsl_lpuart_driver.c fsl_lpuart_driver.h fsl_ltc_common.c fsl_ltc_driver.c fsl_ltc_driver.h fsl_ltc_driver_aes.c fsl_ltc_driver_aes.h fsl_ltc_driver_aes_ccm.c fsl_ltc_driver_hash.c fsl_ltc_driver_hash.h fsl_ltc_driver_prv.h fsl_pit_common.c fsl_pit_driver.c fsl_pit_driver.h fsl_power_manager.c fsl_power_manager.h fsl_power_manager_common.h fsl_rtc_common.c fsl_rtc_driver.c fsl_rtc_driver.h fsl_tpm_common.c fsl_tpm_driver.c fsl_tpm_driver.h fsl_trng_common.c fsl_trng_driver.c fsl_trng_driver.h fsl_tsi_common.c fsl_tsi_driver.c fsl_tsi_driver.h fsl_tsi_v4_driver_specific.c MKW40Z4.h MKW40Z4_extension.h MKW40Z4_features.h
  group KW40_Firmware/Platform/HAL
    Platform/HAL/: fsl_adc16_hal.c fsl_adc16_hal.h fsl_cmp_hal.c fsl_cmp_hal.h fsl_cmt_hal.c fsl_cmt_hal.h fsl_cop_hal.c fsl_cop_hal.h fsl_dac_hal.c fsl_dac_hal.h fsl_dma_hal.c fsl_dma_hal.h fsl_dmamux_hal.c fsl_dmamux_hal.h fsl_dspi_hal.c fsl_dspi_hal.h fsl_gpio_hal.c fsl_gpio_hal.h fsl_i2c_hal.c fsl_i2c_hal.h fsl_llwu_hal.c fsl_llwu_hal.h fsl_lptmr_hal.c fsl_lptmr_hal.h fsl_lpuart_hal.h fsl_ltc_hal.c fsl_ltc_hal.h fsl_mcg_hal.c fsl_mcg_hal.h fsl_mcg_hal_modes.c fsl_mcg_hal_modes.h fsl_misc_utilities.h fsl_pit_hal.c fsl_pit_hal.h fsl_pmc_hal.h fsl_port_hal.c fsl_port_hal.h fsl_rcm_hal.c fsl_rcm_hal.h fsl_rtc_hal.c fsl_rtc_hal.h fsl_sim_hal.h fsl_sim_hal_MKW40Z4.c fsl_sim_hal_MKW40Z4.h fsl_smc_hal.c fsl_smc_hal.h fsl_tpm_hal.c fsl_tpm_hal.h fsl_trng_hal.c fsl_trng_hal.h fsl_tsi_hal.c fsl_tsi_hal.h fsl_tsi_v4_hal_specific.c fsl_tsi_v4_hal_specific.h
